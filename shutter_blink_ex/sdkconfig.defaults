## shutter_blink_ex/sdkconfig.defaults
```kconfig
CONFIG_BLINK_LED_GPIO=y
CONFIG_BLINK_GPIO=2
CONFIG_SPI_FLASH_SUPPORT_BOYA_CHIP=y
```
